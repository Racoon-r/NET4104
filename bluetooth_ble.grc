options:
  parameters:
    author: Racoon
    copyright: 2024 Racoon - GPL-3.0
    description: Implementation of a BLE encoder / decoder
    generate_options: qt_gui
    id: bluetooth_ble
    output_language: python
    title: BLE Implementation
  states: {}

blocks:
- name: ble_freq
  id: variable
  parameters:
    value: 2402e6
  states: {}
- name: cutoff_freq
  id: variable
  parameters:
    value: 850e3
  states: {}
- name: dc_corr
  id: variable
  parameters:
    value: 1.5e6
  states: {}
- name: hackrf_freq
  id: variable
  parameters:
    value: ble_freq+dc_corr
  states: {}
- name: lowpass_filter
  id: variable
  parameters:
    value: firdes.low_pass(1, samp_rate, cutoff_freq, transition_width)
  states: {}
- name: mute
  id: variable_qtgui_range
  parameters:
    start: '-100'
    step: '1'
    stop: '10'
    value: '-20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/symbol_rate
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: transition_width
  id: variable
  parameters:
    value: 300e3
  states: {}
- name: analog_simple_squelch_cc_2
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.1'
    threshold: mute
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ./out_ble
    type: byte
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: int(sps)
    sensitivity: (np.pi*0.5)/sps
  states: {}
- name: freq_xlating_fir_filter_lp
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: lowpass_filter
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-dc_corr'
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    nconnections: '2'
    type: complex
    ymax: '5'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    type: complex
    ymax: '5'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '0'
    clock_source0: internal
    freq0: hackrf_freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '10'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: ref
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: gfsk_in
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: ref
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: gfsk_in
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: ref
  states: {}

connections:
- [analog_simple_squelch_cc_2, '0', qtgui_freq_sink_x_0, '0']
- [analog_simple_squelch_cc_2, '0', virtual_sink_1_0, '0']
- [blocks_uchar_to_float_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_uchar_to_float_1, '0']
- [digital_gfsk_demod_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [freq_xlating_fir_filter_lp, '0', digital_gfsk_demod_0, '0']
- [freq_xlating_fir_filter_lp, '0', qtgui_freq_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_1_0, '0', virtual_sink_1, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_1_0, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_0, '1']
- [virtual_source_0_1, '0', freq_xlating_fir_filter_lp, '0']
- [virtual_source_0_2, '0', analog_simple_squelch_cc_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
